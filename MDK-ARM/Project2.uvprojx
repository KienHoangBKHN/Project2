# Keil uVision project Project2.uvprojx, settings and files
target Project2 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Project2
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Inc;   ../Drivers/STM32F1xx_HAL_Driver/Inc;   ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;   ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;   ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_spi.c stm32f1xx_hal_uart.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal.c stm32f1xx_hal_rtc.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_pwr.c stm32f1xx_hal_cortex.c
  group Radio
    ../Radio/: radio.c radio.h sx1272.c sx1272.h sx1272Regs-Fsk.h sx1272Regs-LoRa.h sx126x.h
  group Board
    ../Board/: board.c board.h rtc-board.c rtc-board.h sx1272_board.c timer.c timer.h sx1272_board.h spi-board.c spi-board.h gpio-board.c gpio-board.h board-config.h pinName-board.h
  group Utilities
    ../Utilities/: delay.c delay.h delay_board.c delay_board.h mybool.h utilities.c utilities.h
  group System
    ../System/: spi.h gpio.c gpio.h
  group Application/User
    ../Src/: main.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/CMSIS
    ..//Src/: system_stm32f1xx.c
  group UserApp
    ./: PingPong.c MacApp.c
    ../MacApp/: Commissioning.h
  group Mac
    ../Mac/: LoRaMac.c LoRaMac.h LoRaMacCrypto.c LoRaMacCrypto.h LoRaMacTest.h
  group Region
    ../Mac/region/: Region.c Region.h RegionAS923.c RegionAS923.h RegionAU915.c RegionAU915.h RegionCN470.c RegionCN470.h RegionCN779.c RegionCN779.h RegionCommon.c RegionCommon.h RegionEU433.c RegionEU433.h RegionEU868.c RegionEU868.h RegionIN865.c RegionIN865.h RegionKR920.c RegionKR920.h RegionUS915.c RegionUS915.h RegionUS915-Hybrid.c RegionUS915-Hybrid.h
  group Crypto
    ../Mac/crypto/: aes.c aes.h cmac.c cmac.h
software components: CMSIS:CORE 4.3.0
